<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\usci_uart_echo.ewp</path>
    </project>
    <batchBuild />
</workspace>
