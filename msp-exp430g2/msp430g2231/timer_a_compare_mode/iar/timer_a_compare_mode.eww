<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\timer_a_compare_mode.ewp</path>
    </project>
    <batchBuild />
</workspace>
