<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rtc_timer_isr.ewp</path>
    </project>
    <batchBuild />
</workspace>
