<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gpio_4_position_switch.ewp</path>
    </project>
    <batchBuild />
</workspace>
